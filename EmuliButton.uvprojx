# Keil uVision project EmuliButton.uvprojx, settings and files
target iButton (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EmuliButton +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;.\Libraries\CMSIS\CM3\CoreSupport;.\App;.\Libraries\MDR32F9Qx_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;.\FourthLevel;.\eiButton
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group StartUp
    ./Libraries/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: startup_MDR32F9Qx.s
  group CMSIS
    ./Libraries/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: system_MDR32F9Qx.c
  group App
    ./App/: main.c
  group FthLevel
    ./FourthLevel/: tims.c systick.c uart.c
    ./FourthLevel/clks/: clks.c
  group MDRDrivers
    ./Libraries/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c MDR32F9Qx_timer.c MDR32F9Qx_eeprom.c MDR32F9Qx_bkp.c MDR32F9Qx_uart.c
  group eiButton
    ./eiButton/: eiButton.c
